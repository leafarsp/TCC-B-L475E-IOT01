# Keil uVision project Project.uvprojx, settings and files
target STM32L496G-Discovery_httpclient (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L496AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L496G-Discovery
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L496xx,USE_HAL_DRIVER,MBEDTLS_CONFIG_FILE=<httpclient_mbedtls_config.h>,ENABLE_IOT_INFO,ENABLE_IOT_DEBUG,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,USE_MBED_TLS,HTTPCLIENT,USE_C2C
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L496G-Discovery;../Inc;../../../../../Common/Shared/Inc;../../../../../Common/httpclient/Inc;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Drivers/BSP/Components/ug96
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\STM32L496G_Discovery.sct
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_lptim.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_dma.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_nor.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_qspi.c stm32l4xx_ll_fmc.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_nand.c stm32l4xx_hal_dac.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_crc.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal.c stm32l4xx_hal_cryp.c stm32l4xx_hal_hash.c stm32l4xx_hal_sram.c stm32l4xx_hal_i2c.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rng.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_can.c stm32l4xx_hal_uart.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_flash.c stm32l4xx_hal_tim.c stm32l4xx_hal_pwr.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: ecdh.c md2.c pkparse.c asn1parse.c x509_csr.c ssl_ciphersuites.c ssl_tls.c pk_wrap.c pem.c entropy_poll.c timing.c ctr_drbg.c cipher_wrap.c memory_buffer_alloc.c cmac.c ssl_srv.c bignum.c rsa.c ecdsa.c padlock.c x509write_csr.c aesni.c threading.c asn1write.c ecp.c platform.c pkcs5.c ecp_curves.c blowfish.c havege.c xtea.c sha1.c md4.c ssl_cli.c ccm.c des.c pkcs11.c ssl_cookie.c version_features.c ssl_cache.c error.c ripemd160.c pkcs12.c x509.c debug.c oid.c md.c entropy.c version.c certs.c dhm.c pk.c sha512.c arc4.c sha256.c hmac_drbg.c md5.c x509_crl.c cipher.c gcm.c camellia.c base64.c aes.c x509_create.c ecjpake.c x509_crt.c x509write_crt.c ssl_ticket.c pkwrite.c md_wrap.c
  group Application/Common
    ../../../../../Common/Shared/Src/: net.c http_lib.c net_tls_mbedtls.c heap.c timedate.c mbedtls_net.c c2c_net.c rfu.c cloud.c iot_flash_config.c STM32CubeRTCInterface.c net_tcp_c2c.c timingSystem.c entropy_hardware_poll.c
    ../Src/: flash_l4.c
  group Application/C2C
    ../Src/: ug96_io.c c2c.c
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../../Drivers/BSP/Components/ug96/: ug96.c
  group Drivers/BSP/STM32L496G-Discovery
    ../../../../../../Drivers/BSP/STM32L496G-Discovery/: stm32l496g_discovery_io.c stm32l496g_discovery.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Application/User
    ../Src/: stm32l4xx_it.c stm32l4xx_hal_msp.c main.c
  group Application/httpclient
    ../../../../../Common/httpclient/Src/: httpclient.c
software components: CMSIS:CORE 4.3.0
