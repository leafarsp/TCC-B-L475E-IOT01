# Keil uVision project Project.uvprojx, settings and files
target STM32L496G-Discovery_GenericMQTT (ARM-ADS)
  device: STM32L496AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L496G-Discovery +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L496xx,USE_HAL_DRIVER,MBEDTLS_CONFIG_FILE=<genmqtt_mbedtls_config.h>,MQTTCLIENT_PLATFORM_HEADER=paho_mqtt_platform.h,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,GENERICMQTT,USE_MBED_TLS,USE_C2C
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L496G-Discovery;../Inc;../../../../../Common/GenericMQTT/Inc;../../../../../Common/Shared/Inc;../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src;../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Middlewares/Third_Party/cJSON;../../../../../../Drivers/BSP/Components/ug96
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\STM32L496G-Discovery.sct
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Application/GenericMQTT
    ../../../../../Common/GenericMQTT/Src/: GenericMQTTXcubeSample.c
  group Doc
    ../: readme.txt
  group Middlewares/Third_Party/MQTTClient-C
    ../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src/: MQTTClient.c
  group Application/User
    ../Src/: stm32l4xx_it.c main.c stm32l4xx_hal_msp.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: camellia.c x509_csr.c pkcs5.c entropy_poll.c havege.c pkcs12.c sha1.c ssl_cli.c pk_wrap.c version_features.c ctr_drbg.c platform.c gcm.c xtea.c ecp.c error.c cmac.c certs.c oid.c ssl_cache.c md.c sha512.c ecjpake.c ecp_curves.c padlock.c x509_crt.c x509_crl.c bignum.c pem.c pkwrite.c pkparse.c des.c ssl_tls.c md4.c ripemd160.c ecdsa.c pk.c version.c cipher.c x509.c ssl_ticket.c asn1write.c arc4.c md_wrap.c dhm.c cipher_wrap.c x509_create.c rsa.c pkcs11.c sha256.c aesni.c ccm.c md2.c ssl_cookie.c hmac_drbg.c blowfish.c x509write_crt.c timing.c threading.c ssl_srv.c memory_buffer_alloc.c x509write_csr.c ssl_ciphersuites.c aes.c debug.c base64.c asn1parse.c md5.c entropy.c ecdh.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_nand.c stm32l4xx_hal_rtc.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_crc.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_can.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal.c stm32l4xx_hal_nor.c stm32l4xx_hal_dac.c stm32l4xx_hal_tim.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_cortex.c stm32l4xx_hal_usart.c stm32l4xx_hal_dma.c stm32l4xx_hal_spi.c stm32l4xx_hal_rng.c stm32l4xx_ll_fmc.c stm32l4xx_hal_i2c.c stm32l4xx_hal_sram.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hash.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_cryp_ex.c
  group Drivers/BSP/STM32L496G-Discovery
    ../../../../../../Drivers/BSP/STM32L496G-Discovery/: stm32l496g_discovery_io.c stm32l496g_discovery.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/Third_Party/cJSON
    ../../../../../../Middlewares/Third_Party/cJSON/: cJSON.c
  group Application/Common
    ../../../../../Common/Shared/Src/: cloud.c mbedtls_net.c c2c_net.c entropy_hardware_poll.c net.c net_tcp_c2c.c iot_flash_config.c paho_timer.c rfu.c net_tls_mbedtls.c STM32CubeRTCInterface.c timedate.c heap.c http_util.c timingSystem.c
    ../Src/: flash_l4.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/Components/ug96/: ug96.c
  group Application/C2C
    ../Src/: ug96_io.c c2c.c
  group Middlewares/Third_Party/MQTTPacket
    ../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTDeserializePublish.c MQTTUnsubscribeServer.c MQTTPacket.c MQTTUnsubscribeClient.c MQTTFormat.c MQTTSerializePublish.c MQTTSubscribeServer.c MQTTConnectServer.c MQTTConnectClient.c MQTTSubscribeClient.c
software components: CMSIS:CORE 4.3.0
