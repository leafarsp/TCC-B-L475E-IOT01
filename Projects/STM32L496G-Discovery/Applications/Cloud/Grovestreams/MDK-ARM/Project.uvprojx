# Keil uVision project Project.uvprojx, settings and files
target STM32L496G-Discovery_Grovestreams (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L496AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L496G-Discovery
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L496xx,USE_HAL_DRIVER,MBEDTLS_CONFIG_FILE=<grovestreams_mbedtls_config.h>,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,USE_MBED_TLS,GROVESTREAMS,USE_C2C
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L496G-Discovery;../Inc;../../../../../Common/Grovestreams/Inc;../../../../../Common/Shared/Inc;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Drivers/BSP/Components/ug96
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\STM32L496G-Discovery.sct
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Application/User
    ../Src/: stm32l4xx_it.c stm32l4xx_hal_msp.c main.c
  group Application/Grovestreams
    ../../../../../Common/Grovestreams/Src/: grovestreams.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/Components/ug96/: ug96.c
  group Application/C2C
    ../Src/: ug96_io.c c2c.c
  group Drivers/BSP/STM32L496G-Discovery
    ../../../../../../Drivers/BSP/STM32L496G-Discovery/: stm32l496g_discovery_io.c stm32l496g_discovery.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Doc
    ../: readme.txt
  group Application/Common
    ../../../../../Common/Shared/Src/: http_lib.c heap.c c2c_net.c STM32CubeRTCInterface.c iot_flash_config.c net.c entropy_hardware_poll.c net_tls_mbedtls.c mbedtls_net.c timedate.c cloud.c net_tcp_c2c.c rfu.c timingSystem.c
    ../Src/: flash_l4.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: pk_wrap.c ecjpake.c ecdh.c pkcs11.c version.c ecp_curves.c md4.c ssl_ticket.c pkparse.c pkcs5.c sha512.c bignum.c ecdsa.c platform.c sha1.c x509_csr.c aes.c error.c md5.c ssl_cache.c timing.c pkcs12.c entropy_poll.c pkwrite.c certs.c md.c memory_buffer_alloc.c ssl_tls.c ssl_cli.c asn1write.c x509write_csr.c pk.c x509_create.c x509write_crt.c ccm.c gcm.c ssl_ciphersuites.c havege.c ssl_srv.c asn1parse.c cipher.c threading.c des.c cipher_wrap.c x509.c md_wrap.c ssl_cookie.c pem.c arc4.c oid.c x509_crl.c base64.c dhm.c sha256.c md2.c version_features.c entropy.c blowfish.c aesni.c ripemd160.c cmac.c rsa.c camellia.c debug.c hmac_drbg.c padlock.c ecp.c x509_crt.c ctr_drbg.c xtea.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_nor.c stm32l4xx_hal_sram.c stm32l4xx_hal.c stm32l4xx_hal_spi.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_cryp.c stm32l4xx_ll_fmc.c stm32l4xx_hal_crc.c stm32l4xx_hal_i2c.c stm32l4xx_hal_usart.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_tim.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_dac.c stm32l4xx_hal_cortex.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_rng.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_uart.c stm32l4xx_hal_can.c stm32l4xx_hal_rcc.c stm32l4xx_hal_qspi.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_hash.c
software components: CMSIS:CORE 4.3.0
