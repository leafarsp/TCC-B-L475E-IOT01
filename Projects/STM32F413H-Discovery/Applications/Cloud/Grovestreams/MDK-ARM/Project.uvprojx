# Keil uVision project Project.uvprojx, settings and files
target STM32F413H_DISCOVERY_Grovestreams (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000-0x817FFFF) IRAM(0x20000000-0x2004FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F413H-Discovery
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F413xx,USE_HAL_DRIVER,USE_STM32F413H_DISCOVERY,MBEDTLS_CONFIG_FILE=<grovestreams_mbedtls_config.h>,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,USE_MBED_TLS,GROVESTREAMS,STM32F413xx,USE_WIFI
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F413H-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../Common/Grovestreams/Inc;../../../../../Common/Shared/Inc;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Drivers/BSP/Components/es_wifi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\STM32F413H_Discovery.sct
  group Application/MDK-ARM
    ./: startup_stm32f413xx.s
  group Doc
    ../: readme.txt
  group Application/Grovestreams
    ../../../../../Common/Grovestreams/Src/: grovestreams.c
  group Application/Common
    ../../../../../Common/Shared/Src/: mbedtls_net.c timedate.c timingSystem.c iot_flash_config.c net_tcp_wifi.c rfu.c STM32CubeRTCInterface.c entropy_hardware_poll.c http_lib.c wifi_net.c heap.c net_tls_mbedtls.c net.c cloud.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: x509_create.c ecp.c ssl_srv.c ssl_cache.c cipher.c oid.c cipher_wrap.c havege.c ssl_cli.c x509.c md_wrap.c x509write_crt.c gcm.c pk.c ssl_tls.c ccm.c ssl_ciphersuites.c debug.c aesni.c rsa.c camellia.c cmac.c ripemd160.c ecdsa.c md2.c blowfish.c version_features.c des.c aes.c pem.c base64.c sha512.c certs.c x509write_csr.c bignum.c ecdh.c pkcs11.c version.c ecjpake.c hmac_drbg.c md4.c entropy.c asn1write.c ctr_drbg.c pk_wrap.c xtea.c x509_crt.c padlock.c platform.c dhm.c memory_buffer_alloc.c entropy_poll.c error.c pkcs12.c pkcs5.c md.c pkwrite.c sha1.c sha256.c ssl_ticket.c ssl_cookie.c md5.c x509_csr.c asn1parse.c threading.c timing.c x509_crl.c arc4.c pkparse.c ecp_curves.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_crc.c stm32f4xx_hal_nand.c stm32f4xx_hal_usart.c stm32f4xx_hal_rng.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_sram.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_lptim.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_hash.c stm32f4xx_hal_qspi.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cortex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dac.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_adc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_nor.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Application/User
    ../Src/: flash_f4.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c
  group Drivers/BSP/STM32F413H-Discovery
    ../../../../../../Drivers/BSP/STM32F413H-Discovery/: stm32f413h_discovery.c
  group Application/Wifi
    ../Src/: wifi.c es_wifi_io.c
software components: CMSIS:CORE 4.3.0
