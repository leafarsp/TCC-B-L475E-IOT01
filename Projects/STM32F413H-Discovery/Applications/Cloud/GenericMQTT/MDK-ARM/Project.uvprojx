# Keil uVision project Project.uvprojx, settings and files
target STM32F413H_DISCOVERY_GenericMQTT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000-0x817FFFF) IRAM(0x20000000-0x2004FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F413H-Discovery +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F413xx,USE_HAL_DRIVER,USE_STM32F413H_DISCOVERY,MBEDTLS_CONFIG_FILE=<genmqtt_mbedtls_config.h>,MQTTCLIENT_PLATFORM_HEADER=paho_mqtt_platform.h,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,GENERICMQTT,USE_MBED_TLS,STM32F413xx,USE_WIFI
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F413H-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../Common/GenericMQTT/Inc;../../../../../Common/Shared/Inc;../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src;../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Middlewares/Third_Party/cJSON;../../../../../../Drivers/BSP/Components/es_wifi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\STM32F413H_Discovery.sct
  group Application/MDK-ARM
    ./: startup_stm32f413xx.s
  group Application/Common
    ../../../../../Common/Shared/Src/: cloud.c mbedtls_net.c timingSystem.c http_util.c net_tcp_wifi.c wifi_net.c rfu.c entropy_hardware_poll.c net_tls_mbedtls.c heap.c timedate.c STM32CubeRTCInterface.c net.c iot_flash_config.c paho_timer.c
  group Middlewares/Third_Party/MQTTClient-C
    ../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src/: MQTTClient.c
  group Application/GenericMQTT
    ../../../../../Common/GenericMQTT/Src/: GenericMQTTXcubeSample.c
  group Application/Wifi
    ../Src/: wifi.c es_wifi_io.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c flash_f4.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_ll_fmc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rtc.c stm32f4xx_hal_nand.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_adc.c stm32f4xx_hal_sram.c stm32f4xx_hal_nor.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_hash.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_lptim.c stm32f4xx_hal_tim.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_can.c stm32f4xx_hal_cryp.c stm32f4xx_hal_adc_ex.c
  group Middlewares/Third_Party/MQTTPacket
    ../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTDeserializePublish.c MQTTUnsubscribeServer.c MQTTConnectClient.c MQTTSubscribeClient.c MQTTPacket.c MQTTUnsubscribeClient.c MQTTSerializePublish.c MQTTConnectServer.c MQTTFormat.c MQTTSubscribeServer.c
  group Doc
    ../: readme.txt
  group Middlewares/Third_Party/cJSON
    ../../../../../../Middlewares/Third_Party/cJSON/: cJSON.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: x509_csr.c camellia.c havege.c entropy_poll.c pkwrite.c debug.c entropy.c asn1parse.c memory_buffer_alloc.c ccm.c x509write_csr.c error.c cmac.c x509write_crt.c ecp_curves.c ssl_cache.c certs.c md2.c ecjpake.c pkcs11.c threading.c ssl_ciphersuites.c md_wrap.c pkcs5.c hmac_drbg.c cipher_wrap.c pk_wrap.c rsa.c aesni.c des.c cipher.c ssl_tls.c version.c ripemd160.c md4.c ssl_ticket.c x509.c aes.c ecdsa.c asn1write.c padlock.c x509_crt.c x509_crl.c md5.c bignum.c pem.c pk.c pkparse.c ecdh.c base64.c sha256.c sha512.c ecp.c timing.c ssl_cookie.c ssl_cli.c blowfish.c ssl_srv.c md.c pkcs12.c sha1.c arc4.c oid.c dhm.c platform.c x509_create.c ctr_drbg.c version_features.c gcm.c xtea.c
  group Drivers/BSP/STM32F413H-Discovery
    ../../../../../../Drivers/BSP/STM32F413H-Discovery/: stm32f413h_discovery.c
software components: CMSIS:CORE 4.3.0
