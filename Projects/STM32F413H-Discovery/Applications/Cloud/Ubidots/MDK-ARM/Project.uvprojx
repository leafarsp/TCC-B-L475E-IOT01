# Keil uVision project Project.uvprojx, settings and files
target STM32F413H_DISCOVERY_Ubidots (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000-0x817FFFF) IRAM(0x20000000-0x2004FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F413H-Discovery
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F413xx,USE_HAL_DRIVER,USE_STM32F413H_DISCOVERY,MBEDTLS_CONFIG_FILE=<ubidots_mbedtls_config.h>,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,USE_MBED_TLS,UBIDOTS,STM32F413xx,USE_WIFI
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F413H-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../Common/Ubidots/Inc;../../../../../Common/Shared/Inc;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Drivers/BSP/Components/es_wifi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\STM32F413H_Discovery.sct
  group Application/MDK-ARM
    ./: startup_stm32f413xx.s
  group Doc
    ../: readme.txt
  group Application/Wifi
    ../Src/: es_wifi_io.c wifi.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: ssl_ticket.c ssl_cli.c debug.c x509_create.c pk.c threading.c xtea.c sha256.c havege.c x509_crt.c bignum.c rsa.c pkcs12.c hmac_drbg.c ripemd160.c asn1write.c md4.c pem.c pkparse.c certs.c base64.c aesni.c ssl_cache.c ssl_tls.c aes.c ssl_srv.c sha1.c x509_csr.c ecjpake.c entropy.c version.c entropy_poll.c sha512.c ecp.c platform.c pkwrite.c camellia.c oid.c dhm.c ecdh.c version_features.c x509write_crt.c pkcs5.c padlock.c pk_wrap.c x509.c md2.c ecp_curves.c ssl_cookie.c x509write_csr.c ssl_ciphersuites.c x509_crl.c md5.c pkcs11.c md.c ccm.c cmac.c cipher_wrap.c cipher.c gcm.c arc4.c des.c md_wrap.c asn1parse.c blowfish.c timing.c ctr_drbg.c ecdsa.c memory_buffer_alloc.c error.c
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c main.c stm32f4xx_it.c flash_f4.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_cryp.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_rng.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_nand.c stm32f4xx_ll_fmc.c stm32f4xx_hal_flash.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dac.c stm32f4xx_hal_nor.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_adc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_can.c stm32f4xx_hal_qspi.c stm32f4xx_hal_usart.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hash.c stm32f4xx_hal_sram.c stm32f4xx_hal_lptim.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rtc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_flash_ex.c
  group Application/Ubidots
    ../../../../../Common/Ubidots/Src/: ubidots.c
  group Application/Common
    ../../../../../Common/Shared/Src/: heap.c rfu.c net.c mbedtls_net.c http_lib.c cloud.c wifi_net.c net_tcp_wifi.c timingSystem.c timedate.c net_tls_mbedtls.c entropy_hardware_poll.c iot_flash_config.c STM32CubeRTCInterface.c
  group Drivers/BSP/STM32F413H-Discovery
    ../../../../../../Drivers/BSP/STM32F413H-Discovery/: stm32f413h_discovery.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
software components: CMSIS:CORE 4.3.0
