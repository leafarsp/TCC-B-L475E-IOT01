# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_Discovery_GenericMQTT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2007FFFF) IRAM(0x00000000-0x3FFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F769I-Discovery +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO,MBEDTLS_CONFIG_FILE=<genmqtt_mbedtls_config.h>,MQTTCLIENT_PLATFORM_HEADER=paho_mqtt_platform.h,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,GENERICMQTT,USE_MBED_TLS,HAS_RTOS,USE_LWIP
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../../Drivers/BSP/Components;../../../../../Common/GenericMQTT/Inc;../../../../../Common/Shared/Inc;../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src;../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Middlewares/Third_Party/cJSON;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Utilities;../../../../../../Utilities/Fonts;../../../../../../Utilities/Log
  asm include: ../Inc;../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\STM32F769I_Discovery.sct
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Middlewares/Third_Party/LwIP/Core/IPV4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: icmp.c igmp.c ip4_addr.c dhcp.c ip4_frag.c autoip.c ip4.c etharp.c
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Doc
    ../: readme.txt
  group Middlewares/Third_Party/LwIP/System
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dac_ex.c stm32f7xx_hal_nand.c stm32f7xx_hal_adc.c stm32f7xx_hal_flash.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_hash.c stm32f7xx_hal_rtc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_spi.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_sram.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_dac.c stm32f7xx_hal_can.c stm32f7xx_hal_i2c_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_qspi.c stm32f7xx_hal_dma.c stm32f7xx_hal_lptim.c stm32f7xx_hal_pwr.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_tim.c stm32f7xx_hal_wwdg.c stm32f7xx_hal_usart.c stm32f7xx_hal_cryp.c stm32f7xx_hal.c stm32f7xx_hal_nor.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rng.c stm32f7xx_hal_uart.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_adc_ex.c
  group Middlewares/Third_Party/MQTTPacket
    ../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTConnectServer.c MQTTSubscribeClient.c MQTTFormat.c MQTTSubscribeServer.c MQTTConnectClient.c MQTTDeserializePublish.c MQTTUnsubscribeServer.c MQTTUnsubscribeClient.c MQTTPacket.c MQTTSerializePublish.c
  group Middlewares/Third_Party/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: netbuf.c netifapi.c sockets.c err.c api_msg.c tcpip.c netdb.c api_lib.c
  group Application/Common
    ../../../../../Common/Shared/Src/: net_tcp_lwip.c net_tls_mbedtls.c paho_timer.c timingSystem.c heap.c STM32CubeRTCInterface.c timedate.c mbedtls_net.c http_util.c net.c iot_flash_config.c entropy_hardware_poll.c rfu.c lwip_net.c cloud.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c tasks.c timers.c queue.c
  group Middlewares/Third_Party/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c
  group Application/GenericMQTT
    ../../../../../Common/GenericMQTT/Src/: GenericMQTTXcubeSample.c
  group Middlewares/Third_Party/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: pbuf.c netif.c raw.c inet_chksum.c tcp_in.c udp.c def.c tcp_out.c dns.c tcp.c memp.c init.c ip.c sys.c stats.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/BSP/STM32F769I-Discovery
    ../../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c
  group Application/User
    ../Src/: main.c stm32f7xx_it.c stm32f7xx_hal_timebase_tim.c stm32f7xx_hal_msp.c ethernetif.c flash_f7.c
  group Middlewares/Third_Party/cJSON
    ../../../../../../Middlewares/Third_Party/cJSON/: cJSON.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/MQTTClient-C
    ../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src/: MQTTClient.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c bignum.c padlock.c arc4.c ssl_ticket.c ssl_ciphersuites.c version.c md5.c ssl_tls.c pkcs11.c sha512.c ripemd160.c ecp.c x509.c base64.c pkcs12.c x509write_csr.c oid.c entropy.c dhm.c platform.c x509_create.c x509write_crt.c blowfish.c xtea.c ctr_drbg.c ssl_cookie.c ccm.c des.c ecdh.c ssl_srv.c asn1parse.c asn1write.c sha256.c timing.c pkcs5.c pkwrite.c memory_buffer_alloc.c sha1.c ssl_cli.c camellia.c pk_wrap.c debug.c gcm.c version_features.c md2.c hmac_drbg.c md.c threading.c havege.c pem.c x509_crl.c x509_crt.c md_wrap.c pkparse.c aesni.c rsa.c cipher_wrap.c cipher.c entropy_poll.c error.c cmac.c md4.c ecp_curves.c ecjpake.c ecdsa.c pk.c x509_csr.c certs.c ssl_cache.c
  group Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: timeouts.c mem.c
software components: CMSIS:CORE 4.3.0
