# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_Discovery_Ubidots (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2007FFFF) IRAM2(0x00000000-0x3FFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F769I-Discovery
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO,MBEDTLS_CONFIG_FILE=<ubidots_mbedtls_config.h>,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,USE_MBED_TLS,UBIDOTS,HAS_RTOS,USE_LWIP
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../../Drivers/BSP/Components;../../../../../Common/Ubidots/Inc;../../../../../Common/Shared/Inc;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Utilities;../../../../../../Utilities/Fonts;../../../../../../Utilities/Log
  asm include: ../Inc;../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x4000
  scatter file: .\STM32F769I_Discovery.sct
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Drivers/BSP/STM32F769I-Discovery
    ../../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c
  group Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: timeouts.c mem.c
  group Application/User
    ../Src/: ethernetif.c stm32f7xx_hal_msp.c main.c flash_f7.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/Third_Party/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c
  group Middlewares/Third_Party/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: netbuf.c netifapi.c err.c netdb.c api_lib.c tcpip.c api_msg.c sockets.c
  group Application/Common
    ../../../../../Common/Shared/Src/: heap.c lwip_net.c rfu.c net_tls_mbedtls.c iot_flash_config.c net.c timedate.c entropy_hardware_poll.c STM32CubeRTCInterface.c timingSystem.c mbedtls_net.c cloud.c http_lib.c net_tcp_lwip.c
  group Middlewares/Third_Party/LwIP/Core/IPV4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c etharp.c ip4_addr.c ip4_frag.c dhcp.c igmp.c icmp.c ip4.c
  group Application/Ubidots
    ../../../../../Common/Ubidots/Src/: ubidots.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: udp.c tcp.c inet_chksum.c init.c tcp_out.c dns.c memp.c tcp_in.c ip.c def.c sys.c pbuf.c netif.c stats.c raw.c
  group Doc
    ../: readme.txt
  group Middlewares/Third_Party/LwIP/System
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: threading.c md4.c platform.c pkparse.c pem.c ecdsa.c ssl_tls.c memory_buffer_alloc.c ecp.c x509_crt.c ssl_ticket.c sha1.c debug.c bignum.c x509_create.c havege.c ssl_srv.c aesni.c md_wrap.c cipher.c ripemd160.c xtea.c ccm.c md.c ecdh.c md5.c ssl_cli.c pk.c gcm.c version_features.c pkcs5.c pk_wrap.c pkcs11.c error.c entropy.c pkwrite.c ssl_ciphersuites.c camellia.c x509write_crt.c cipher_wrap.c x509_crl.c md2.c x509.c blowfish.c ctr_drbg.c timing.c asn1parse.c sha512.c des.c arc4.c entropy_poll.c aes.c ssl_cookie.c base64.c hmac_drbg.c cmac.c version.c certs.c dhm.c ecjpake.c sha256.c asn1write.c padlock.c x509_csr.c x509write_csr.c pkcs12.c ecp_curves.c ssl_cache.c oid.c rsa.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_flash.c stm32f7xx_hal.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_spi.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_nor.c stm32f7xx_hal_rcc.c stm32f7xx_hal_sram.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_wwdg.c stm32f7xx_hal_uart.c stm32f7xx_hal_dma.c stm32f7xx_hal_dac.c stm32f7xx_hal_cryp.c stm32f7xx_hal_adc.c stm32f7xx_hal_lptim.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_cryp_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_rng.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_qspi.c stm32f7xx_hal_nand.c stm32f7xx_hal_tim.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_hash.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_i2c.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_cortex.c stm32f7xx_hal_can.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: timers.c queue.c list.c tasks.c
software components: CMSIS:CORE 4.3.0
