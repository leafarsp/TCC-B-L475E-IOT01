# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_Discovery_Exosite (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2007FFFF) IRAM2(0x00000000-0x3FFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F769I-Discovery
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO,MBEDTLS_CONFIG_FILE=<exosite_mbedtls_config.h>,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,USE_MBED_TLS,EXOSITEHTTP,HAS_RTOS,USE_LWIP
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../../Drivers/BSP/Components;../../../../../Common/Exosite/Inc;../../../../../Common/Shared/Inc;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Utilities;../../../../../../Utilities/Fonts;../../../../../../Utilities/Log
  asm include: ../Inc;../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x4000
  scatter file: .\STM32F769I_Discovery.sct
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Application/Exosite
    ../../../../../Common/Exosite/Src/: exositehttp.c
  group Middlewares/Third_Party/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: tcpip.c netdb.c err.c netbuf.c netifapi.c api_lib.c api_msg.c sockets.c
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/Third_Party/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/BSP/STM32F769I-Discovery
    ../../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c
  group Middlewares/Third_Party/LwIP/System
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: tcp_in.c tcp.c ip.c netif.c init.c sys.c dns.c raw.c stats.c memp.c tcp_out.c inet_chksum.c def.c udp.c pbuf.c
  group Application/Common
    ../../../../../Common/Shared/Src/: http_lib.c net_tls_mbedtls.c cloud.c lwip_net.c heap.c timedate.c entropy_hardware_poll.c rfu.c net.c STM32CubeRTCInterface.c net_tcp_lwip.c timingSystem.c iot_flash_config.c mbedtls_net.c
  group Middlewares/Third_Party/LwIP/Core/IPV4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: etharp.c autoip.c ip4_addr.c igmp.c icmp.c dhcp.c ip4_frag.c ip4.c
  group Application/User
    ../Src/: stm32f7xx_hal_msp.c stm32f7xx_it.c main.c stm32f7xx_hal_timebase_tim.c ethernetif.c flash_f7.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: timers.c queue.c list.c tasks.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: ecdsa.c version.c x509_csr.c certs.c ecp.c bignum.c md.c gcm.c ssl_tls.c aesni.c ccm.c havege.c ssl_srv.c debug.c x509_create.c entropy_poll.c sha512.c memory_buffer_alloc.c cipher.c md_wrap.c platform.c base64.c md2.c x509_crt.c x509write_crt.c pk.c ssl_ticket.c sha1.c ssl_cli.c md5.c xtea.c pkcs5.c ecdh.c md4.c pem.c pkparse.c ripemd160.c ctr_drbg.c ssl_cache.c timing.c blowfish.c x509.c x509write_csr.c version_features.c pk_wrap.c pkwrite.c aes.c error.c entropy.c camellia.c rsa.c sha256.c ecjpake.c x509_crl.c ecp_curves.c padlock.c asn1write.c pkcs12.c arc4.c asn1parse.c dhm.c oid.c pkcs11.c threading.c des.c cipher_wrap.c hmac_drbg.c ssl_cookie.c cmac.c ssl_ciphersuites.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_sram.c stm32f7xx_hal_i2c.c stm32f7xx_hal_wwdg.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_rtc.c stm32f7xx_hal_dac.c stm32f7xx_hal_adc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_lptim.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_eth.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_hash.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_rng.c stm32f7xx_hal_crc.c stm32f7xx_hal_nand.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dma.c stm32f7xx_ll_fmc.c stm32f7xx_hal_uart.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_nor.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_flash.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_pwr_ex.c
  group Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: mem.c timeouts.c
software components: CMSIS:CORE 4.3.0
