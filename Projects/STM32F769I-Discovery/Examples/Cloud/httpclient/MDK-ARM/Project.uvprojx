# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_Discovery_httpclient (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2007FFFF) IRAM(0x00000000-0x3FFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F769I-Discovery
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO,MBEDTLS_CONFIG_FILE=<httpclient_mbedtls_config.h>,ENABLE_IOT_INFO,ENABLE_IOT_DEBUG,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,USE_MBED_TLS,HTTPCLIENT,HAS_RTOS,USE_LWIP
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../../Drivers/BSP/Components;../../../../../Common/Shared/Inc;../../../../../Common/httpclient/Inc;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Utilities;../../../../../../Utilities/Fonts;../../../../../../Utilities/Log
  asm include: ../Inc;../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\STM32F769I_Discovery.sct
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_rtc.c stm32f7xx_hal_hash.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_rcc.c stm32f7xx_hal_usart.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_crc.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal.c stm32f7xx_hal_dac.c stm32f7xx_hal_spi.c stm32f7xx_hal_gpio.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_qspi.c stm32f7xx_hal_hash_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma.c stm32f7xx_hal_nand.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_nor.c stm32f7xx_hal_lptim.c stm32f7xx_hal_pwr.c stm32f7xx_hal_i2c.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_rng.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_wwdg.c
  group Middlewares/Third_Party/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c ethernet.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: entropy_poll.c pk_wrap.c timing.c ecp_curves.c cipher_wrap.c pem.c cmac.c sha1.c platform.c ssl_ciphersuites.c bignum.c xtea.c pkparse.c blowfish.c ecdh.c hmac_drbg.c dhm.c threading.c ecp.c md4.c pk.c ccm.c ssl_srv.c sha512.c rsa.c aesni.c certs.c asn1parse.c asn1write.c padlock.c entropy.c memory_buffer_alloc.c oid.c ecdsa.c md.c x509_crt.c debug.c x509.c pkcs5.c ssl_cookie.c havege.c ssl_cli.c pkcs11.c error.c version.c ripemd160.c md_wrap.c des.c x509write_csr.c pkcs12.c x509write_crt.c ssl_cache.c x509_crl.c pkwrite.c x509_csr.c ecjpake.c aes.c ssl_ticket.c x509_create.c md2.c md5.c base64.c cipher.c arc4.c ssl_tls.c gcm.c camellia.c sha256.c version_features.c ctr_drbg.c
  group Middlewares/Third_Party/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: sys.c ip.c dns.c init.c memp.c udp.c tcp_out.c inet_chksum.c raw.c def.c tcp_in.c tcp.c pbuf.c netif.c stats.c
  group Doc
    ../: readme.txt
  group Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: mem.c timeouts.c
  group Middlewares/Third_Party/LwIP/Core/IPV4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c autoip.c icmp.c ip4.c etharp.c igmp.c ip4_frag.c dhcp.c
  group Application/httpclient
    ../../../../../Common/httpclient/Src/: httpclient.c
  group Drivers/BSP/STM32F769I-Discovery
    ../../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c
  group Application/User
    ../Src/: main.c stm32f7xx_it.c stm32f7xx_hal_msp.c ethernetif.c stm32f7xx_hal_timebase_tim.c flash_f7.c
  group Middlewares/Third_Party/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: netifapi.c tcpip.c netbuf.c api_msg.c err.c api_lib.c sockets.c netdb.c
  group Middlewares/Third_Party/LwIP/System
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Application/Common
    ../../../../../Common/Shared/Src/: http_lib.c net_tls_mbedtls.c iot_flash_config.c heap.c entropy_hardware_poll.c cloud.c lwip_net.c rfu.c net.c net_tcp_lwip.c STM32CubeRTCInterface.c mbedtls_net.c timingSystem.c timedate.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c queue.c list.c timers.c
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
software components: CMSIS:CORE 4.3.0
